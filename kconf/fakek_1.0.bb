SUMMARY = "Stand-in for linux-xlnx: sets the audit level the same way"
LICENSE = "CLOSED"
KCONF_AUDIT_LEVEL="0"
