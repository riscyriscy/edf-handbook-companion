FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://no-telnet.cfg"
