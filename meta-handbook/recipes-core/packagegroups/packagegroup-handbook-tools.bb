SUMMARY = "Diagnostic tools for the handbook image"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = "pciutils usbutils ethtool"
