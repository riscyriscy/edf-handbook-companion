FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://debugfs.cfg file://pstore.cfg"
